# Keil uVision project 2g4_tx_rx_slp.uvprojx, settings and files
target 2g4_tx_rx_slp (6160000::V6.16::ARMCLANG)
  device: TS800X Techstorm
  pack: TechStorm.DFP.1.0.0
  cpu: IRAM(0x20000900,0x00005700) IRAM2(0x20000000,0x00000000) IROM(0x10000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: 2g4_tx_rx_slp +hex
  AfterMake: ..\..\..\..\tools\ble_after_build.bat @L ..\..\..\..
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=3
  c misc: -fno-short-wchar
  c include: ..\include;..\..\..\..\modules\drv;..\..\..\..\soc\ts800x;..\..\..\..\soc\m0;..\..\..\..\modules\debug;..\..\..\..\modules\debug\RTT;..\..\..\..\modules\2g4
  asm include: ..\..\..\..\soc\m0
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000900 size 0x5700
  scatter file: ..\..\..\..\soc\ts800x\platform\keil\ts8001_2G4.sct
  link misc: --datacompressor=off --diag_suppress=L6314,L6329,L6170Wt
  group user
    ../source/: main.c
  group lib
    ../source/: 2g4_slp_lib.a
    ../../../../soc/ts800x/lib/: ts800x_2G4_lib.lib
  group drv
    ../../../../modules/drv/: ts800x_ll_gpio.c ts800x_ll_gpio.h ts800x_hal_uart.c ts800x_hal_uart.h ts800x_hal_systick.c ts800x_hal_systick.h ts800x_flash.c ts800x_flash.h
  group soc
    ../source/: system_init.c ts800x_it_2g4.c ts800x_sleep_2g4.c context_switch.S
    ../../../../soc/ts800x/platform/keil/: ts800x_startup.s
    ../../../../soc/ts800x/: ts800x_otp_cfg.c
  group debug
    ../../../../modules/debug/: log.c uart_dbg.c
    ../../../../modules/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../modules/debug/assert/: assert.c
